Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 4d6aac02-b02d-4d3f-8077-8e07fab629d5, NumberOfSaves: 38], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_FallProtection_AOS01A4.ifc
Time: 2025-07-18T15:03:30
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Attrezzature speciali : ROTHOB_Rothoblaas_FallProtection_AOS01A4 : 60x98mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteelAISI316
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_AOS01; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-points/aos01; Revision: 001; UniClass2015Code: Pr_40_70_75_75; UniClass2015Title: Safety access anchor devices; UniClass2015Version: Products v1.38; Version: 003
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI316
Type - Quote - Length_L: 98 mm; Width_B: 60 mm
Type - Dati identità - Descrizione: Anchor point; Nome del tipo: 60x98mm; Numero OmniClass: 23.27.71.21; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Attrezzature speciali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_75 - Safety access anchor devices; CodePerformance: Safety system; Color: Silver; Constituents: Fastening (nuts, washers); DurationUnit: Years; ExpectedLife: n/a; Features: Anchor point; Finish: n/a; Grade: n/a; GTIN: n/a; Material: AISI 316 stainless steel grade 1.4401; MinWeight: 0.257 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: AOS01A4; ModelReference: n/a; Name: Anchor point; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_AOS01A4; NominalHeight: n/a; NominalLength: 98 mm; NominalWidth: 60 mm; ReferenceStandard: with TOWER/TOWERA2/SHIELD/SHIELD2: EN 795:2012 A | CEN/TS 16415:2013 | UNI 11578:2015 A | AS/NZS 5532:2013 | AS/NZS 1891.4:2009 // with TOWERXL: EN 795:2012 A | CEN/TS 16415:2013 A | UNI 11578:2015 A // with T-CLAMP: EN 795:2012 A | CEN/TS 16415:2013 | UNI 11578:2015 A | AS/NZS 5532:2013 // with WAVE/COPPO: EN 795:2012 A | CEN/TS 16415:2013 | UNI 11578:2015 A // with BLOCK: EN 795:2012 E; ReplacementCost: n/a; Shape: Three-dimensional; Size: 60x98 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Anchor point; Category: Pr_40_70_75_75 - Safety access anchor devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: 60x98mm; sets with these values: 2
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Volume: 0.0000245413 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_AOS01A4; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_AOS01A4: 60x98mm; ID tipo: 450063; Tipo: 60x98mm
